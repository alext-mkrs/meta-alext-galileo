FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://gspca_pac207_webcam.cfg"
