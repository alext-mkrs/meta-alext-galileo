FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://rt2800usb.cfg"
