FILESEXTRAPATHS := "${THISDIR}/files:"

SRC_URI += "\
	   file://fix-build-gcc-4.8.patch \
"
