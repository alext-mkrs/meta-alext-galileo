EXTRA_OECONF += " \
    --disable-asm \
"

PR = "8.1"